# Keil uVision project stm32f407vgt6.uvprojx, settings and files
target stm32f407vgt6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407vgt6
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\..\source\include;..\..\source\ip\st\STM32F4xx_HAL_Driver\Inc;..\..\source\ip\st\STM32F4xx_HAL_Driver;..\..\source\ip\arm\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group entry
    ../../source/entry/: isr.c main.c system.c entry.s
  group ip
    ../../source/ip/arm/: itm.c
    ../../source/ip/st/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c
    ../../source/ip/st/STM32F4xx_HAL_Driver/: system_stm32f4xx.c
  group hal
    ../../source/ip/st/hal/: clocktree.c gpio.c
